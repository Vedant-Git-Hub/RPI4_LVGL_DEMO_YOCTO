SUMMARY = "LVGL video player"
require photo-app-common.inc
RDEPENDS:${PN} = "ffmpeg alsa-utils-aplay kernel-module-snd-usb-audio"
