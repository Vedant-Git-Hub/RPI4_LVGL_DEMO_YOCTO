# The video app requests SDL's KMSDRM backend and an OpenGL ES renderer.
PACKAGECONFIG:append = " kmsdrm gles2"
