SUMMARY = "LVGL image viewer"
require recipes-apps/photo-common/photo-app-common.inc
RDEPENDS:${PN} = "imagemagick"
