SUMMARY = "LVGL camera, network, image, video and audio settings"
require photo-app-common.inc
RDEPENDS:${PN} = "wpa-supplicant-cli imagemagick ffmpeg"
