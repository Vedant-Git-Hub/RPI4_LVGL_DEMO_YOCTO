# Add JPEG 2000 to the broad raster format set used by the gallery.
PACKAGECONFIG:append = " openjpeg"
DEPENDS:append = " libraw"
