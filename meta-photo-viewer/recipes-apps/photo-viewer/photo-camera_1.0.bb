SUMMARY = "LVGL USB camera application"
require photo-app-common.inc
RDEPENDS:${PN} = "photo-camera-service"
