SUMMARY = "LVGL app drawer and child process supervisor"
require photo-app-common.inc
RDEPENDS:${PN} = "photo-images photo-videos photo-settings photo-camera"
