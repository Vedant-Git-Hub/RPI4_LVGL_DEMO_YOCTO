SUMMARY = "LVGL image viewer"
require photo-app-common.inc
RDEPENDS:${PN} = "imagemagick"
